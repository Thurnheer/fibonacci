## unittests/testcase.yaml
```yaml
common:
  tags: fibonacci fib
  harness: ztest

tests:
  components.fibonacci.turn_on:
    tags: sw_test
```
